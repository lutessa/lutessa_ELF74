<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\TivaWare\examples\boards\ek-tm4c129exl\blinky\blinky.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\TivaWare\driverlib\driverlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab\Lab.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab1\lab1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab2\Lab2.ewp</path>
    </project>
    <batchBuild />
</workspace>
