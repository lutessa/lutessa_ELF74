# IAR project ProjetoFinal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C129ENCPDT TexasInstruments TM4C129ENCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT; ewarm; PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.CCIncludePath2: ..\..\ThreadX\ports\cortex_m4\iar\inc; ..\..\ThreadX\common\inc; ..\..\ThreadX\common\src; ..\..\TivaWare; ..\..\ThreadX
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab6a.srec
  ILINK.IlinkOutputFile: Lab5.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h sample_threadx.c startup_TM4C1294.s system_TM4C1294.c system_TM4C1294.h TM4C1294NCPDT.h tx_initialize_low_level.s
    ../../TivaWare/driverlib/ewarm/Exe/: driverlib.a
    ../../ThreadX/ports/cortex_m4/iar/example_build/Debug/Exe/: tx.a
